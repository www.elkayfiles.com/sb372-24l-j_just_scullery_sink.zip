Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-27T19:00:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 27 19:00:52 2023 * Host: ZIL2DTCLS3 * Database: C:\Users\cdprasad\AppData\Local\Temp\30d0481a-f91d-4480-b3a1-bd862c611d9d\874ac385-c65f-4307-8d74-994b2b648d9f\ifc * Database version: 5507 * Database creation date: Wed Dec 27 19:00:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 27 19:00:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 27 19:00:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: SB372-24L-J:SB372-24L-J, SB372-24L-J:SB372-24L-J:763169
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: SB372-24L-J
Pset_DistributionFlowElementCommon - Reference: SB372-24L-J; sets with these values: 2
